# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\ADC;..\HARDWARE\SMG;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SMG/: smg.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group README
    ../: README.TXT
